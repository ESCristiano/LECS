# Keil uVision project LECS.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LECS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Code
    ./: main.cpp CLecs.cpp CSensors.cpp CCapSensors.cpp CLightSensor.cpp CMicrophone.cpp CTimer.cpp C2DLedMatrix.cpp C3DLedMatrix.cpp C3DLedMatrixBuffer.cpp CLayer.cpp CQueue.cpp libPDMFilter_Keil.lib
  group Headers
    ./: CBoardLeds.h CLecs.h CSensors.h CCapSensors.h CLightSensor.h CMicrophone.h CTimer.h C2DLedMatrix.h C3DLedMatrix.h C3DLedMatrixBuffer.h CLayer.h main.h freertos.h CQueue.h
  group Documentation
    ./: Abstract.txt notes.txt
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
